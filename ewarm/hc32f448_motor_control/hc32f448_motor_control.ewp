# IAR project hc32f448_motor_control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32F448MCTI XHSC HC32F448MCTI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F448; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\source; ..\..\device; ..\..\device\hc32f448; ..\..\device\hc32f448\mcu_driver; ..\..\device\hc32f448\mcu_driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f46x_motor_control.hex
  ILINK.IlinkOutputFile: hc32f46x_motor_control.out
  ILINK.IlinkIcfFile: config\linker\HC32F448xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\source; ..\..\device; ..\..\device\hc32f460; ..\..\device\hc32f460\mcu_driver; ..\..\device\hc32f460\mcu_driver\inc
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: hc32f46x_motor_control.srec
  ILINK.IlinkIcfFile: config\linker\HC32F460xE.icf
  group (top)
    ../../source/: readme.txt
  group mcu_common
    ../../device/mcu_common/: mcu_include.h
  group mcu_config
    ../../device/hc32f448/mcu_config/: hardware_config.c init_mcu.c isr.c
  group mcu_driver
    ../../device/hc32f448/mcu_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_tmr4.c hc32_ll_utility.c hc32_ll_wdt.c
    ../../device/hc32f448/mcu_driver/: system_hc32f448.c
  group motor_midwares
    ../../source/motor_midwares/: adc_sample.c coordinate_transform.c filter.c flux_observer.c module_math.c pid.c protection.c speed_set.c startup_control.c stop_control.c svpwm.c
  group motor_source
    ../../source/motor_source/: cmd_set_analog_io.c main.c motor_control.c user_interface.c
  group startup
    startup/: startup_hc32f448.s
