# Keil uVision project hc32f448_motor_control0.uvprojx, settings and files
target hc32f448_motor_control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.0.1
  cpu: IRAM(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x40000) IROM2(0x03000C00,0x400) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f448_motor_control0 +hex
  AfterMake: fromelf  --elf -o "$L@L.elf" "#L"
  AfterMake: fromelf --bin !L --output hc32.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: __DEBUG,HC32F448,USE_DDL_DRIVER
  c include: ..\..\device\hc32f448;..\..\device\hc32f448\mcu_driver;..\..\device\hc32f448\mcu_driver\inc;..\..\device;..\..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x3000c00 size 0x400
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group mcu_commom
    ../../device/mcu_common/: mcu_include.h
  group mcu_config
    ../../device/hc32f448/mcu_config/: hardware_config.c init_mcu.c isr.c
  group mcu_driver
    ../../device/hc32f448/mcu_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_tmr4.c hc32_ll_utility.c hc32_ll_wdt.c
    ../../device/hc32f448/mcu_driver/: system_hc32f448.c
  group motor_midwares
    ../../source/motor_midwares/: adc_sample.c coordinate_transform.c filter.c flux_observer.c module_math.c pid.c protection.c speed_set.c startup_control.c stop_control.c svpwm.c
  group motor_source
    ../../source/motor_source/: cmd_set_analog_io.c main.c motor_control.c user_interface.c
  group startup
    ./: startup_hc32f448.s
software components: CMSIS:CORE 5.3.0
